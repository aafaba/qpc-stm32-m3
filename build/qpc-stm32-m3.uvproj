# Keil uVision project qpc-stm32-m3.uvproj, settings and files
target qpc-stm32-m3 (ARM-ADS)
  device: STM32F103R8 STMicroelectronics
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(72000000) ELITTLE
  output: qpc-stm32-m3
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER
  c misc: --c99
  c include: ../;../include;F:\qp\qpc\include;F:\qp\qpc\ports\arm-cm\vanilla\arm_keil;F:\st\STM32F10x_StdPeriph_Lib_V3.5.0\Libraries\CMSIS\CM3\CoreSupport;F:\st\STM32F10x_StdPeriph_Lib_V3.5.0\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x;F:\st\STM32F10x_StdPeriph_Lib_V3.5.0\Libraries\STM32F10x_StdPeriph_Driver\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group startup
    F:/st/STM32F10x_StdPeriph_Lib_V3.5.0/Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_md.s
  group main
    ../src/: main.c
  group st
    F:/st/STM32F10x_StdPeriph_Lib_V3.5.0/Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
    F:/st/STM32F10x_StdPeriph_Lib_V3.5.0/Libraries/CMSIS/CM3/CoreSupport/: core_cm3.c
    F:/st/STM32F10x_StdPeriph_Lib_V3.5.0/Libraries/STM32F10x_StdPeriph_Driver/src/: stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c
  group qpc
    F:/qp/qpc/qep/source/: qmsm_ini.c qmsm_in.c qmsm_dis.c qhsm_top.c qhsm_ini.c qhsm_in.c qhsm_dis.c qfsm_ini.c qfsm_dis.c qep.c
    F:/qp/qpc/qf/source/: qa_ctor.c qa_defer.c qa_fifo.c qa_get_.c qa_lifo.c qa_sub.c qa_usub.c qa_usuba.c qeq_fifo.c qeq_get.c qeq_init.c qeq_lifo.c qf_act.c qf_gc.c qf_log2.c qf_new.c qf_pool.c qf_psini.c qf_pspub.c qf_pwr2.c qf_tick.c qma_ctor.c qmp_get.c qmp_init.c qmp_put.c qte_arm.c qte_ctor.c qte_ctr.c qte_darm.c qte_rarm.c qvanilla.c
  group node
    ../src/node/: log.c
  group driver
    ../src/driver/: serial.c
  group port
    ../src/port/: qpc_handler.c
  group qm
    ../src/qm/: qm_leds.c
